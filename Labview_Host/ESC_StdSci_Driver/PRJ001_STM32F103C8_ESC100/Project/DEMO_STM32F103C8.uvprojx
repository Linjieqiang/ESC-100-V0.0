# Keil uVision project DEMO_STM32F103C8.uvprojx, settings and files
target TARTGET (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TARGET001 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CMSIS\include;..\Hardware\include;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Basic\sys;..\Basic\delay;..\Basic\usart;..\Basic\flash;..\Basic\ESC_StandardSCI_Protocol;..\User\include;..\App\ESC_StandardSCI_Communication
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/source/: core_cm3.c system_stm32f10x.c
  group Startup
    ../Startup/: startup_stm32f10x_md.s
  group User
    ../User/source/: main.c stm32f10x_it.c
  group Basic
    ../Basic/sys/: sys.c
    ../Basic/delay/: delay.c
    ../Basic/usart/: usart.c
    ../Basic/flash/: flash.c
    ../Basic/ESC_StandardSCI_Protocol/: ESC_StandardSCI_Protocal.c
  group STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_flash.c misc.c stm32f10x_gpio.c stm32f10x_usart.c
  group App
    ../App/ESC_StandardSCI_Communication/: ESC_StandardSCI_Receive.c ESC_StandardSCI_Send.c
